<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\ASR6505\LoRaShouChi\LoRaShouChi.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\Projects\PingPong\EWSTM8\project.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Sensor.ewp</path>
    </project>
    <batchBuild />
</workspace>
