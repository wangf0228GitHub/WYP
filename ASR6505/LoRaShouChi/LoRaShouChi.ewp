# IAR project LoRaShouChi.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152M8 STM8L152M8
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\STM8L15x_StdPeriph_Driver\inc; ..\SDKV20; ..\STM8L15x_StdPeriph_Driver; $PROJ_DIR$; F:\work\WF_Device
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: FlagDefine.h HardwareProfile.h LoraProc.c LoraProc.h main.c PickParamDefine.h stm8l15x_it.c SystemInit.c Variables.c Variables.h
  group Function
    ./: FRAM.c FRAM.h
  group SDKV20
    ../SDKV20/: delay.c delay.h radio.c radio.h Sx1262Proc.c Sx1262Proc.h sx126x.c sx126x.h TMRList.c TMRList.h
  group STM8L15x_StdPeriph_Driver
    ../STM8L15x_StdPeriph_Driver/: stm8_interrupt_vector.c stm8l15x_conf.h stm8l15x_it.h
  group STM8L15x_StdPeriph_Driver/inc
    ../STM8L15x_StdPeriph_Driver/inc/: stm8l15x.h stm8l15x_adc.h stm8l15x_aes.h stm8l15x_beep.h stm8l15x_clk.h stm8l15x_comp.h stm8l15x_dac.h stm8l15x_dma.h stm8l15x_exti.h stm8l15x_flash.h stm8l15x_gpio.h stm8l15x_i2c.h stm8l15x_irtim.h stm8l15x_itc.h stm8l15x_iwdg.h stm8l15x_lcd.h stm8l15x_pwr.h stm8l15x_rst.h stm8l15x_rtc.h stm8l15x_spi.h stm8l15x_syscfg.h stm8l15x_tim1.h stm8l15x_tim2.h stm8l15x_tim3.h stm8l15x_tim4.h stm8l15x_tim5.h stm8l15x_usart.h stm8l15x_wfe.h stm8l15x_wwdg.h
  group STM8L15x_StdPeriph_Driver/src
    ../STM8L15x_StdPeriph_Driver/src/: stm8l15x_aes.c stm8l15x_clk.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_iwdg.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wwdg.c
  group wf
    ../../../WF_Device/: CharTimeOP.c CharTimeOP.h CP1616_Client.c CP1616_Client.h DS1302.c DS1302.h SimSPI.c SimSPI.h SPIROM.c SPIROM.h Verify.c Verify.h wfDefine.h
